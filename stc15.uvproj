# Keil uVision project stc15.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F408AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: stc15测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib\Inc;.\user;.\user
  group user
    ./user/: Interrupt.c main.c
  group lib
    ./lib/Src/: delay.c uart.c NFR24L01.c OLED12864.c oledcode.c key_final_version.c
